# Keil uVision project firmware_XIP.uvprojx, settings and files
target firmware_ln882h (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: firmware_XIP
  BeforeMake: python    ..\..\..\tools\python_scripts\sdk_env_check.py
  BeforeMake: python3 ..\..\..\tools\python_scripts\before_build_keil.py  -p  ..\cfg\flash_partition_cfg.json -o  ..\cfg\flash_partition_table.h
  AfterMake: python3  ..\..\..\tools\python_scripts\after_build_keil.py  -k   #P   -o flashimage.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LN882H,ARM_MATH_CM4
  c misc: --gnu --diag_suppress=1,177,550
  c include: ..\..\..\components\ble\app;..\..\..\components\ble\ble_api\common;..\..\..\components\ble\ble_api\gap_gatt\api;..\..\..\components\ble\ble_lib_import;..\..\..\components\ble\mac\ble\hl\api;..\..\..\components\ble\mac\ble\hl\inc;..\..\..\components\ble\mac\ble\ll\api;..\..\..\components\ble\mac\ble\ll\import;..\..\..\components\ble\mac\ble\ll\src;..\..\..\components\ble\mac\ble\ll\src\llm;..\..\..\components\ble\mac\ble\profiles\netcfg\api;..\..\..\components\ble\mac\em\api;..\..\..\components\ble\mac\hci\api;..\..\..\components\ble\mac\sch\api;..\..\..\components\ble\mac\sch\import;..\..\..\components\ble\modules\aes\api;..\..\..\components\ble\modules\common\api;..\..\..\components\ble\modules\dbg\api;..\..\..\components\ble\modules\ecc_p256\api;..\..\..\components\ble\modules\h4tl\api;..\..\..\components\ble\modules\ke\api;..\..\..\components\ble\modules\lib_ver\api;..\..\..\components\ble\modules\nvds\api;..\..\..\components\ble\modules\rf\api;..\..\..\components\ble\modules\rwip\api;..\..\..\components\net\lwip-2.1.3\src\include;..\..\..\components\net\lwip-2.1.3\src\port\ln_osal\include;..\..\..\components\wifi\wifi_manager;..\..\..\components\wifi\wifi_lib_import;..\..\..\components\wifi\wifi_lib_export;..\..\..\components\fs\nvds;..\..\..\components\fs\partition_mgr;..\..\..\components\fs\kv\kv_port;..\..\..\components\fs\kv\kv;..\..\..\components\serial;..\..\..\components\net\dhcpd;..\..\..\components\net\iperf;..\..\..\components\net\ping;..\..\..\components\kernel;..\..\..\components\kernel\FreeRTOS\Source\include;..\..\..\components\kernel\FreeRTOS_Adapter;..\..\..\components\kernel\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\components\utils\debug\runtime;..\..\..\components\utils\debug\reboot_trace;..\..\..\components\utils;..\..\..\components;..\..\..\mcu\driver_ln882h;..\..\..\mcu\driver_ln882h\reg;..\..\..\mcu\CMSIS_5.3.0;..\..\..\mcu\ln882h;..\..\..\components;..\..\..\components\ln_at;..\..\..\components\ln_at\adapter;..\..\..\components\ln_at\cmd;..\..\..\components\ln_at\parser;..\..\..\components\ln_at\transfer;..\..\..\components\ln_at_cmd\system;..\cfg;..\bsp;..\app;..\app_callback;..\..\..\components\ble\ble_profiles\prf_common;..\..\..\components\ble;..\..\..\components\ble\ble_arch;..\..\..\components\tencent\qcloud_iot_c_sdk\include;..\..\..\components\tencent\qcloud_iot_c_sdk\include\exports;..\..\..\components\tencent\qcloud_iot_c_sdk\sdk_src\internal_inc;..\..\..\components\tencent\qcloud_iot_c_sdk\external_libs\cJSON;..\..\..\components\tencent\LLSync\config;..\..\..\components\tencent\LLSync\inc;..\..\..\components\tencent\LLSync\src\internal_inc;..\..\..\components\tencent\LLSync\data_template;..\..\..\components\utils\linux_compat;..\..\..\components\ble\ble_app\ble_connection_manager;..\..\..\components\ble\ble_arch;..\..\..\components\ble\ble_app\ble_device_manager;..\..\..\components\ble\ble_app\ble_gap\gap_advertising;..\..\..\components\ble\ble_app\ble_gap\gap_misc;..\..\..\components\ble\ble_app\ble_gap\gap_scan;..\..\..\components\ble\ble_app\ble_gatt\gatt_client;..\..\..\components\ble\ble_app\ble_gatt\gatt_common;..\..\..\components\ble\ble_app\ble_gatt\gatt_server;..\..\..\components\ble\ble_app\ble_event;..\..\..\components\ble\ble_app\ble_smp;..\..\..\components\ble\ble_app\ble_import;..\..\..\components\ble\ble_app\ble_store;..\..\..\components\ble;..\..\..\components\ble\ble_app\ble_common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\ln882h.sct
  link misc: --keep=*.o(.no_init_data)
  group cpu
    ../startup/: startup_ln882h.S
    ../../../mcu/ln882h/: system_ln882h.c ln882h.h ln882h_rom_fun.h mem_map_ln882h.h base_addr_ln882h.h
  group ln882h_hal
    ../../../mcu/driver_ln882h/hal/: hal_cache.c hal_common.c hal_flash.c hal_qspi.c hal_uart.c hal_wdt.c hal_trng.c hal_gpio.c hal_interrupt.c hal_clock.c hal_misc.c hal_ext.c hal_timer.c hal_adc.c hal_efuse.c
  group bsp
    ../bsp/: serial_hw.c drv_adc_measure.c
  group util
    ../../../components/utils/debug/: ln_assert.c log.c
    ../../../components/utils/fifo/: fifobuf.c
    ../../../components/utils/: crc32.c wrap_stdio.c system_parameter.c ln_psk_calc.c ln_sha1.c ln_misc.c ln_aes.c
    ../../../components/utils/debug/CmBacktrace/: cm_backtrace.c
    ../../../components/utils/reboot_trace/: reboot_trace.c
    ../../../components/utils/runtime/: runtime.c
    ../../../components/utils/power_mgmt/: ln_pm.c
    ../../../components/utils/linux_compat/: linux_compat_time.c
  group app
    ../app/: main.c usr_app.c
  group at_cmd
    ../../../components/ln_at/adapter/: ln_at_adapt.c
    ../../../components/ln_at/cmd/: ln_at_cmd.c ln_at_cmd_basic.c
    ../../../components/ln_at/parser/: ln_at_parser.c
    ../../../components/ln_at/transfer/: ln_at_transfer.c
    ../../../components/ln_at/: ln_at.c ln_at_server.c
    ../../../components/ln_at_cmd/system/: ln_at_cmd_system.c
    ../../../components/ln_at_cmd/net/: ln_at_cmd_net_test.c
    ../../../components/ln_at_cmd/wifi/: ln_at_cmd_wifi.c
  group FreeRTOS
    ../../../components/kernel/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../components/kernel/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../components/kernel/FreeRTOS/: hooks.c
    ../../../components/kernel/FreeRTOS/Source/portable/MemMang/: heap_5.c
  group FreeRTOS_Adapter
    ../../../components/kernel/FreeRTOS_Adapter/: freertos_debug.c freertos_mutex.c freertos_queue.c freertos_semaphore.c freertos_thread.c freertos_timer.c freertos_common.c freertos_cpuusage.c
    ../../../components/kernel/osal/: osal.h
  group serial
    ../../../components/serial/: serial.c
  group net
    ../../../components/net/ping/: ping.c
    ../../../components/net/dhcpd/: dhcp_packet.c dhcpd.c ip_allocator.c
    ../../../components/net/iperf/: iperf.c
  group fs
    ../../../components/fs/partition_mgr/: flash_partition_mgr.c
    ../../../components/fs/nvds/: ln_nvds.c
    ../../../components/fs/kv/kv/: ln_kv.c
    ../../../components/fs/kv/kv_port/: ln_kv_port.c
  group lib
    ../../../lib/armcclib/: arm_cortexM4lf_math.lib ln882h_wifi.lib ln882h_ble_full_stack.lib
  group wifi_manager
    ../../../components/wifi/wifi_manager/: wifi_manager.c
  group wifi_lib_import
    ../../../components/wifi/wifi_lib_import/: wifi_port.c wifi_port.h ln_wifi_err.h
  group ble_lib_import
    ../../../components/ble/ble_lib_import/: ble_port.c ble_port.h
    ../../../components/ble/ble_arch/: ble_arch_main.c
  group ble_app
    ../../../components/ble/ble_app/ble_connection_manager/: ln_ble_connection_manager.c
    ../../../components/ble/ble_app/ble_device_manager/: ln_ble_device_manager.c
    ../../../components/ble/ble_app/ble_event/: ln_ble_event_manager.c
    ../../../components/ble/ble_app/ble_gap/gap_advertising/: ln_ble_advertising.c
    ../../../components/ble/ble_app/ble_gap/gap_misc/: ln_ble_gap.c ln_ble_gap_ind_handler.c
    ../../../components/ble/ble_app/ble_gap/gap_scan/: ln_ble_scan.c
    ../../../components/ble/ble_app/ble_gatt/gatt_client/: ln_ble_trans_client.c
    ../../../components/ble/ble_app/ble_gatt/gatt_common/: ln_ble_gatt.c ln_ble_gatt_ind_handler.c
    ../../../components/ble/ble_app/ble_gatt/gatt_server/: ln_ble_trans_server.c
    ../../../components/ble/ble_app/ble_import/: ln_ble_rw_app_task.c
    ../../../components/ble/ble_app/ble_store/: ln_ble_app_kv.c
    ../../../components/ble/ble_app/ble_smp/: ln_ble_smp.c
  group ble_profile
    ../../../components/ble/ble_profiles/prf_common/: prf_ble.c prf_utils.c
  group lwip213/core
    ../../../components/net/lwip-2.1.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip-2.1.3/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../components/net/lwip-2.1.3/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip213/api
    ../../../components/net/lwip-2.1.3/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip213/netif
    ../../../components/net/lwip-2.1.3/src/netif/: ethernet.c
  group lwip213/port/ln_osal
    ../../../components/net/lwip-2.1.3/src/port/ln_osal/arch/: sys_arch.c
    ../../../components/net/lwip-2.1.3/src/port/ln_osal/netif/: ethernetif.c
    ../../../components/net/lwip-2.1.3/src/port/ln_osal/include/: lwipopts.h
  group qc_exlibs/cJSON
    ../../../components/tencent/qcloud_iot_c_sdk/external_libs/cJSON/: cJSON.c cJSON_Utils.c
  group qc_src/network
    ../../../components/tencent/qcloud_iot_c_sdk/sdk_src/network/socket/: network_socket.c
    ../../../components/tencent/qcloud_iot_c_sdk/sdk_src/network/: network_interface.c
  group qc_src/protocol
    ../../../components/tencent/qcloud_iot_c_sdk/sdk_src/protocol/http/: utils_httpc.c utils_url_download.c utils_url_upload.c
    ../../../components/tencent/qcloud_iot_c_sdk/sdk_src/protocol/mqtt/: mqtt_client.c mqtt_client_common.c mqtt_client_connect.c mqtt_client_net.c mqtt_client_publish.c mqtt_client_subscribe.c mqtt_client_unsubscribe.c mqtt_client_yield.c
  group qc_src/servers
    ../../../components/tencent/qcloud_iot_c_sdk/sdk_src/services/data_template/: data_template_action.c data_template_client.c data_template_client_common.c data_template_client_json.c data_template_client_manager.c data_template_event.c
    ../../../components/tencent/qcloud_iot_c_sdk/sdk_src/services/device_bind/: device_bind.c
    ../../../components/tencent/qcloud_iot_c_sdk/sdk_src/services/location/: location.c
    ../../../components/tencent/qcloud_iot_c_sdk/sdk_src/services/ota/: ota_client.c ota_fetch.c ota_lib.c ota_mqtt.c
    ../../../components/tencent/qcloud_iot_c_sdk/sdk_src/services/resource/: resource_client.c resource_lib.c resource_mqtt.c resource_upload.c
    ../../../components/tencent/qcloud_iot_c_sdk/sdk_src/services/service_com/: service_mqtt.c
    ../../../components/tencent/qcloud_iot_c_sdk/sdk_src/services/dynreg/: dynreg.c
  group qc_src/utils
    ../../../components/tencent/qcloud_iot_c_sdk/sdk_src/utils/: json_parser.c json_token.c qcloud_iot_ca.c qcloud_iot_device.c qcloud_iot_log.c string_utils.c utils_aes.c utils_base64.c utils_getopt.c utils_hmac.c utils_list.c utils_md5.c utils_ringbuff.c utils_sha1.c utils_timer.c
  group qc_src/wifi_config
    ../../../components/tencent/qcloud_iot_c_sdk/sdk_src/wifi_config/: qcloud_wifi_config.c qcloud_wifi_config_comm_service.c qcloud_wifi_config_device_bind.c qcloud_wifi_config_error_handle.c qcloud_wifi_config_log_handle.c
  group qc_platform/os
    ../../../components/tencent/qcloud_iot_c_sdk/platform/os/freertos/: HAL_Device_freertos.c HAL_OS_freertos.c HAL_TCP_lwip.c HAL_Timer_freertos.c HAL_UDP_lwip.c
  group qc_platform/tls
    ../../../components/tencent/qcloud_iot_c_sdk/platform/tls/mbedtls/: HAL_DTLS_mbedtls.c HAL_TLS_mbedtls.c
  group qc_platform/wifi
    ../../../components/tencent/qcloud_iot_c_sdk/platform/wifi_config_adapter/: HAL_BTCombo_config.c HAL_Soft_ap.c HAL_Wifi_api.c HAL_Airkiss.c HAL_Simple_config.c HAL_Smart_config.c HAL_LN_Wifi.c
  group qc_sample
    ../../../components/tencent/qcloud_iot_c_sdk/samples/wifi_config/: wifi_config_sample.c
  group LLSync_header
    ../../../components/tencent/LLSync/config/: ble_qiot_config.h
    ../../../components/tencent/LLSync/inc/: ble_qiot_export.h ble_qiot_import.h
    ../../../components/tencent/LLSync/src/internal_inc/: ble_qiot_aes.h ble_qiot_common.h ble_qiot_crc.h ble_qiot_hmac.h ble_qiot_llsync_data.h ble_qiot_llsync_device.h ble_qiot_llsync_event.h ble_qiot_llsync_ota.h ble_qiot_log.h ble_qiot_md5.h ble_qiot_param_check.h ble_qiot_service.h ble_qiot_sha1.h ble_qiot_utils_base64.h
  group LLSync_src/core
    ../../../components/tencent/LLSync/src/core/: ble_qiot_llsync_data.c ble_qiot_llsync_device.c ble_qiot_llsync_event.c ble_qiot_llsync_ota.c ble_qiot_llsync_utils.c ble_qiot_service.c
  group LLSync_src/utils
    ../../../components/tencent/LLSync/src/utils/: ble_qiot_utils_aes.c ble_qiot_utils_base64.c ble_qiot_utils_crc.c ble_qiot_utils_hmac.c ble_qiot_utils_log.c ble_qiot_utils_md5.c ble_qiot_utils_sha1.c
  group LLSync_hal
    ../../../components/tencent/LLSync/hal/: hal_ble_qiot_import.c
  group LLSync_data_template
    ../../../components/tencent/LLSync/data_template/: ble_qiot_template.c
