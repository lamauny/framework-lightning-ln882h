# Keil uVision project libzj_net_os.uvprojx, settings and files
target libzj_net_os (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: libzj_net_os (library)
  AfterMake: cmd.exe /C copy .\Objects\@L.lib ..\..\..\lib\armcclib\@L.lib
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LN882H, ARM_MATH_CM4, MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,CONFIG_DEBUG_LOG_LEVEL=1
  c misc: --gnu --diag_suppress=1295,1
  c include: ..\..\..\mcu\CMSIS_5.3.0;..\..\..\mcu\ln882h;..\..\zj_iot\zengge_iot_wf_bt_ldp\zengge_app\zj_app;..\..\zj_iot\zengge_iot_wf_bt_ldp\zj_net_os\zj-common\sys;..\..\zj_iot\zengge_iot_wf_bt_ldp\zj_net_os\zj-common\net;..\..\zj_iot\zengge_iot_wf_bt_ldp\zj_net_os\sdk\ln_sdk\zj_adapt;..\..\zj_iot\zengge_iot_wf_bt_ldp\zj_net_os\adapter_common;..\..\..\components\net\lwip-2.1.3\src\include;..\..\..\components\net\lwip-2.1.3\src\port\ln_osal\include;..\..\..\components\kernel;..\..\..\components\kernel\FreeRTOS\Source\include;..\..\..\components\kernel\FreeRTOS_Adapter;..\..\..\components\kernel\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\bsp;.\app;.\cfg;..\..\..\components\utils\linux_compat;..\..\..\components\utils;..\..\..\components\utils\debug\runtime;..\..\..\components\utils\debug\reboot_trace;..\..\..\components;..\..\..\components\net\mbedtls\port_ln\include;..\..\..\components\net\mbedtls\include;..\..\zj_iot\zengge_iot_wf_bt_ldp\zj_net_os\zj-common\socket;..\..\zj_iot\zengge_iot_wf_bt_ldp\zj_net_os\zj-common\utils;..\..\zj_iot\zengge_iot_wf_bt_ldp\zj_net_os\zj-common\zj_ota;..\..\zj_iot\zengge_iot_wf_bt_ldp\zj_net_os\zj-common\store_kv;..\..\zj_iot\zengge_iot_wf_bt_ldp\zj_net_os\zj-common\rmt_scene;..\..\zj_iot\zengge_iot_wf_bt_ldp\zj_net_os\zj-common\quicklz;..\..\zj_iot\zengge_iot_wf_bt_ldp\zj_net_os\zj-common\lz4;..\..\zj_iot\zengge_iot_wf_bt_ldp\zj_net_os\zj-common\dynamic_sync;..\..\zj_iot\zengge_iot_wf_bt_ldp\zj_net_os\zj-common\btr;..\..\zj_iot\zengge_iot_wf_bt_ldp\zj_net_os\zj-common\app_general_funtion;..\..\zj_iot\zengge_iot_wf_bt_ldp\zj_net_os\zj-common\proto_dpc;..\..\zj_iot\zengge_iot_wf_bt_ldp\zengge_app\zj_app\include;..\..\zj_iot\zengge_iot_wf_bt_ldp\zengge_app\zj_app\iic_l_cfg;..\..\zj_iot\zengge_iot_wf_bt_ldp\zengge_app\zj_app\src;..\..\zj_iot\zengge_iot_wf_bt_ldp\zengge_app\new_cmd_app\include;..\..\..\components\wifi\wifi_lib_export;..\..\..\components\wifi\wifi_lib_import;..\..\..\components\wifi\wifi_manager;..\..\zj_iot\zengge_iot_wf_bt_ldp\zj_net_os\zj-common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep=*.o(.no_init_data)
  group include
    ../../zj_iot/zengge_iot_wf_bt_ldp/zengge_app/zj_app/include/: dev_command_head.h dev_common.h dev_key.h dev_system.h iic_drv_BP5758D.h iic_drv_SM2135Ex.h iic_drv_SM2235Ex.h key_handle.h light_ac_monitor.h light_clock.h light_dynamic.h light_main.h light_mic.h light_night_lamp.h light_remote.h light_touch.h pwr_opt_record.h simulateIIC.h
  group iic_I_cfg
    ../../zj_iot/zengge_iot_wf_bt_ldp/zengge_app/zj_app/iic_I_cfg/BP/: BP101_cfg.h BP102_cfg.h BP103_cfg.h BP104_cfg.h BP105_cfg.h BP106_cfg.h BP107_cfg.h BP108_cfg.h BP109_cfg.h BP110_cfg.h BP111_cfg.h BP112_cfg.h BP113_cfg.h BP114_cfg.h
    ../../zj_iot/zengge_iot_wf_bt_ldp/zengge_app/zj_app/iic_I_cfg/EGH/: EGH101_cfg.h EGH102_cfg.h EGH103_cfg.h EGH104_cfg.h EGH105_cfg.h EGH106_cfg.h EGH107_cfg.h EGH108_cfg.h
    ../../zj_iot/zengge_iot_wf_bt_ldp/zengge_app/zj_app/iic_I_cfg/EH/: EH101_cfg.h EH102_cfg.h EH103_cfg.h EH104_cfg.h
    ../../zj_iot/zengge_iot_wf_bt_ldp/zengge_app/zj_app/iic_I_cfg/EJ/: EJ101_cfg.h
    ../../zj_iot/zengge_iot_wf_bt_ldp/zengge_app/zj_app/iic_I_cfg/IH/: IH9W_cfg.h IH9WL_cfg.h
    ../../zj_iot/zengge_iot_wf_bt_ldp/zengge_app/zj_app/iic_I_cfg/: IIC_chip_inf.h
  group zj_app
    ../../zj_iot/zengge_iot_wf_bt_ldp/zengge_app/zj_app/: attr_dev0E_cfg.h attr_dev1E_cfg.h attr_dev06_cfg.h attr_dev07_cfg.h attr_dev08_cfg.h attr_dev21_cfg.h attr_dev29_cfg.h attr_dev33_cfg.h attr_dev35_cfg.h attr_dev41_cfg.h attr_dev48_cfg.h attr_dev52_cfg.h attr_dev62_cfg.h dev_main.c version_config.h
  group adapter_common
    ../../zj_iot/zengge_iot_wf_bt_ldp/zj_net_os/adapter_common/: zj_adapt_api.h zj_adapter_evt.c
  group sdk/ln_sdk/zj_adapt
    ../../zj_iot/zengge_iot_wf_bt_ldp/zj_net_os/sdk/ln_sdk/zj_adapt/: zj_adapt_ble.c zj_adapt_gpio.c zj_fota_adapt.c zj_iic_adapt.c zj_ir_adapt.c zj_pwm_adapt.c zj_rtc_time.c zj_sys_adapt.c zj_wlan_adapt.c
